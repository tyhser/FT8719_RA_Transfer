# Keil uVision project FT8719_RA_Transfer.uvprojx, settings and files
target FT8719_RA_Transfer (ARM-ADS)
  device: STM32F205RGTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.8.0
  cpu: IROM(0x08000000,0x00100000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FT8719_RA_Transfer
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F2XX
  c include: ..\CORE;..\HARDWARE\KEY;..\HARDWARE\SPI;..\HARDWARE\W25QXX;..\PROTOCAL;..\STM32F2xx_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\MALLOC;..\NODELIST;..\CRC
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CORE
    ../CORE/: core_cm3.c startup_stm32f2xx.s
  group USER
    ./: main.c stm32f2xx_it.c system_stm32f2xx.c
  group FWLib
    ../STM32F2xx_FWLib/src/: misc.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c
  group HARDWARE
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/W25QXX/: w25qxx.c
  group PROTOCAL
    ../PROTOCAL/: protocal.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CRC
    ../CRC/: crc.c
  group MALLOC
    ../MALLOC/: malloc.c
  group NODELIST
    ../NODELIST/: NodeList.c
